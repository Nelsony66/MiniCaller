# IAR project MiniCaller.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MiniCaller.hex
  ILINK.IlinkOutputFile: MiniCaller.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../FWlib/src/: stm8l15x_usart.c
  group FWlib
    ../FWlib/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_wwdg.c
  group USER
    ../USER/: global.c key.c led.c main.c rf.c stm8l15x_it.c syniotRoundRF.c
